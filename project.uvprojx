# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.12.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: SKIP_SYSCLK_INIT, CPU_MIMXRT1052CVL5B, USB_STACK_BM, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, XIP_EXTERNAL_FLASH=1, EVK_MCIMXRM, RT_USING_ARM_LIBC
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: .;rt-thread\include;applications;.;board;board\MCUX_Config;board\ports;libraries\drivers;libraries\drivers\config;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;libraries\MIMXRT1050\CMSIS\Include;libraries\MIMXRT1050\MIMXRT1052;libraries\MIMXRT1050\MIMXRT1052\drivers;libraries\middleware\usb\include;libraries\middleware\usb\device;libraries\middleware\usb\host;libraries\middleware\usb\host\class;libraries\middleware\usb\device;libraries\middleware\usb\osa;libraries\middleware\usb\phy;libraries\middleware\usb\templates\config
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/usb_host_hid_mouse/: app.c host_mouse.c
  group Drivers
    board/: board.c
    board/MCUX_Config/: clock_config.c pin_mux.c
    libraries/drivers/: drv_uart.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/cputime/: cputime.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stubs.c
    rt-thread/components/libc/compilers/common/: time.c
  group Libraries
    libraries/MIMXRT1050/MIMXRT1052/: system_MIMXRT1052.c
    libraries/MIMXRT1050/MIMXRT1052/drivers/: fsl_common.c fsl_clock.c fsl_cache.c fsl_lpuart.c
    libraries/MIMXRT1050/MIMXRT1052/arm/: startup_MIMXRT1052.s
  group usb
    libraries/middleware/usb/host/: usb_host_devices.c usb_host_ehci.c usb_host_framework.c usb_host_hci.c
    libraries/middleware/usb/host/class/: usb_host_hub.c usb_host_hid.c usb_host_hub_app.c
    libraries/middleware/usb/phy/: usb_phy.c
    libraries/middleware/usb/osa/: usb_osa_bm.c
